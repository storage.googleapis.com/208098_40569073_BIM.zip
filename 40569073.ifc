Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-04-26T18:55:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 26 18:55:26 2024 * Host: DESKTOP-13TP49N * Database: C:\Users\andre\AppData\Local\Temp\8a4ff089-cb36-42f2-8fd8-901cdd0d1ac6\d88d5702-1c57-4ad5-ab7b-252101aac113\ifc * Database version: 5507 * Database creation date: Fri Apr 26 18:55:26 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 26 18:55:26 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 26 18:55:26 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowController: 40569073 Cover part for bath and shower faucet, 40569073:40569073 Cover part for bath and shower faucet:34125
In: Level 1
Type - PredefinedType: FAUCET
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - NominalDepth: 92.2933 mm; NominalHeight: 149.982 mm; NominalWidth: 149.984 mm
Type - General - Author: BIMStone; BIMObjectName: 40569073; ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_07; Uniclass2015Description: Bath manual water supply sets; Uniclass2015Reference: Pr_40_20_87_07; Version: 1; VersionDate: 20/04/2024
Type - Green Building Properties - EAN Number: 4057304003738; EN Standard: EN 1111; ETIM Class Number: EC010546 Mechanical control system for shower; Sales Package dimensions (LxWxH): 204 x 186 x 174; UNSPSC Class Number: 30181810 Faucet trim; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/40569073; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL REACH: http://static.hansa.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.hansa.com/bim/40569073; 3D View: https://static.hansa.com/AR/40569073; Catalog Drawing URL: http://static.hansa.com/catdrw/40569073; Dimension Drawing URL: http://static.hansa.com/dimdrw/40569073; FDV Document URL: http://www.hansa.com/datasheet/40569073/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/40569073; Group: Bath and shower faucet; Installation and Maintenance Guide URL: http://static.hansa.com/manual/40569073; Interactive AR View URL: https://static.hansa.com/AR/40569073; Manufacturer: HANSA; Market: International;Germany;Austria;Belgium;Netherlands;Czech Republic;Slovakia;Italy;Spain; Mobile Product Information URL: http://mpi.hansa.com/40569073; Model: 40569073 Cover part for bath and shower faucet; Name_en: 40569073 Cover part for bath and shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 40569073; Product Family: HANSAVAROX Pro; Product Image URL: http://static.hansa.com/image/40569073; Product URL: http://static.hansa.com/40569073; Spare-Part Information URL: http://static.hansa.com/sp/40569073; Technical DataSheet URL: http://www.hansa.com/datasheet/40569073/en; Type Name: 40569073 Cover part for bath and shower faucet; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Mechanical - Backflow Prevention EN1717: EB; Concealed Parts: Square rosette;Fastening of the function unit with screws; Flow Rate At 300kPa: 0.012007 m3/s; Installation Type: Concealed wall mounting; Lever Handle: Temperature control handle; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Thermostatic cartridge for automatic temperature control;Non-return valve(s); Surface treatment: Chrome; Temperature Adjustments: Adjustable hot water stop (included, retrofittable);Safety stop against scalding at 38°C; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 40569073; Features: Thermostatic;Trim Kit; Finish: Polished; Grade: n/a; ModelNumber: n/a; ModelReference: 40569073; Name: 40569073 Cover part for bath and shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 150x95x150 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0501796 m2; Volume: 0.00207612 m3
Identity Data - Mark: 15
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 40569073: 40569073 Cover part for bath and shower faucet; Family and Type: 40569073: 40569073 Cover part for bath and shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 40569073: 40569073 Cover part for bath and shower faucet; Type Id: 40569073: 40569073 Cover part for bath and shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
